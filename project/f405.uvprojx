# Keil uVision project f405.uvprojx, settings and files
target f405 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: f405 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c misc: --c99
  c include: ..\Libraries;..\Mylib;..\User;..\project;..\Mylib\IIC;..\Mylib\MPU6050;..\Mylib\MPU6050\eMPL;..\Mylib\delay;..\Mylib\sys;..\Mylib\usart;..\DSP_LIB;..\DSP_LIB\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_it.c
  group Libraries
    ../Libraries/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h core_sc000.h core_sc300.h misc.c misc.h startup_stm32f4xx.s stm32f4xx.h stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_can.c stm32f4xx_can.h stm32f4xx_crc.c stm32f4xx_crc.h stm32f4xx_cryp.c stm32f4xx_cryp.h stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dac.h stm32f4xx_dbgmcu.c stm32f4xx_dbgmcu.h stm32f4xx_dcmi.c stm32f4xx_dcmi.h stm32f4xx_dma.c stm32f4xx_dma.h stm32f4xx_exti.c stm32f4xx_exti.h stm32f4xx_flash.c stm32f4xx_flash.h stm32f4xx_fsmc.c stm32f4xx_fsmc.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_hash.c stm32f4xx_hash.h stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_iwdg.c stm32f4xx_iwdg.h stm32f4xx_pwr.c stm32f4xx_pwr.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_rng.c stm32f4xx_rng.h stm32f4xx_rtc.c stm32f4xx_rtc.h stm32f4xx_sdio.c stm32f4xx_sdio.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_syscfg.c stm32f4xx_syscfg.h stm32f4xx_tim.c stm32f4xx_tim.h stm32f4xx_usart.c stm32f4xx_usart.h stm32f4xx_wwdg.c stm32f4xx_wwdg.h system_stm32f4xx.c system_stm32f4xx.h
  group DSP_LIB
    ../DSP_LIB/: arm_cortexM4lf_math.lib
  group Lib
    ../Mylib/: board.c can2.c pid.c dbus.c control.c timer.c fdbus.c imu.c mpu6050Bot.c mpu6050Top.c myiic.c mymath.c can1.c softiic1.c softiic2.c yaw_control.c pitch_control.c friction.c
